KBRANCH ?= "foxconn-dev-4.4"
LINUX_VERSION ?= "4.4"
SRCREV="ca35f36d916c6c93cefeabed070bb7e668c593a3"

require linux-obmc.inc
