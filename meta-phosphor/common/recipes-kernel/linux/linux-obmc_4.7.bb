LINUX_VERSION ?= "4.7"
SRCREV="36fedf0b02b33a4f000d92c0425fbebf05774b8c"

require common/recipes-kernel/linux/linux-obmc.inc
