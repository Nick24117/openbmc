KBRANCH ?= "foxconn-g2-4.13 "
LINUX_VERSION ?= "4.13.16"

SRCREV="34b742f797ab5baf9ff804b5326f019ad3a7a60c"

require linux-obmc.inc
