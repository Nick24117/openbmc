SUMMARY = "OpenBMC fan command tool"
DESCRIPTION = "OpenBMC fan command tool."
PR = "r1"

inherit skeleton-sdbus
inherit pkgconfig

SKELETON_DIR = "fan_tool"

