DEPENDS += "i2c-tools"
SRCREV ?= "46e6c760dfc4628f7f6089530c3fce24dae84442"
SKELETON_URI ?= "git://github.com/foxconn-bmc-ks/skeleton;branch=foxconn-g2"
