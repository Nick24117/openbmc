FOXCONN_BRANCH="foxconn-g2"
SRC_URI += "git://github.com/foxconn-bmc-ks/phosphor-networkd;branch=${FOXCONN_BRANCH}"
SRCREV = "b9e5c2c78a24b16fa921bf8c6d54b135b58baefd"
