SUMMARY = "Barreleye board wiring"
DESCRIPTION = "Board wiring information for the Barreleye system."
HOMEPAGE = "http://github.com/foxconn-bmc-ks/skeleton"
PR = "r1"

SRCREV = "2b2535c5d03edd131a32eea401cf79f1c9e01d88"
inherit config-in-skeleton
inherit obmc-phosphor-license
