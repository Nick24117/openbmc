DEPENDS_append = " \
        openpower-debug-collector-native \
        openpower-dbus-interfaces-native \
        openpower-occ-control-native \
        "
