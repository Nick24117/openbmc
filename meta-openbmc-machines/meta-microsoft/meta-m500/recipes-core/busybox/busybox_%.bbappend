FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	    file://no_user_account_manipulation_tools.cfg \
           "
