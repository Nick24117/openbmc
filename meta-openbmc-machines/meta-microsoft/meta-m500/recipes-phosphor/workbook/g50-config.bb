SUMMARY = "G50 board wiring"
DESCRIPTION = "Board wiring information for the G50 system."
HOMEPAGE = "git://csibmc@csibmc.visualstudio.com:22/G50/_git/skeleton;protocol=ssh;"
PR = "r1"

SRCREV = "3c4b38e29a7ff6bb9125639723d8f63653439ecf"
inherit config-in-skeleton
inherit obmc-phosphor-license
