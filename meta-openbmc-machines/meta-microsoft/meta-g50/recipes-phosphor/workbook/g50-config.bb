SUMMARY = "G50 board wiring"
DESCRIPTION = "Board wiring information for the G50 system."
HOMEPAGE = "git://csibmc@csibmc.visualstudio.com:22/G50/_git/skeleton;protocol=ssh;"
PR = "r1"

SRCREV = "33e6cfbaf57fe72d5578cd398ac2427af2968c90"
inherit config-in-skeleton
inherit obmc-phosphor-license
